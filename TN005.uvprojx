# Keil uVision project TN005.uvprojx, settings and files
target NRF_51822 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.3.2
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TN005 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NRF51 BSP_DEFINES_ONLY
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\TN005.sct
  group Temp sensor v2
    ./: main.c micro_esb.c twi_hw_master.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.3.2, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 4.0.0-2.alpha
